options:
  parameters:
    author: bri
    generate_options: qt_gui
    id: modes_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '1090000000'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '''/home/bri/workspace/mode_s_decode/controlpathsdotcom/raw_adsb_files/adsb_raw_''+samp_rate_string+''Hz_''+timestamp+''_mag_char'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: samp_rate_string
  id: variable
  parameters:
    value: str(int(samp_rate))
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: str(int(time()))
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    alias: mag
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.017'
    init: '0'
    low: '0.01'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      #
      # ADS-B / Mode-S receiver for PlutoSDR
      # GNU Radio 3.10 — embedded Python block handles all signal processing:
      #   preamble detection → bit extraction → CRC check → hex output
      #
      # Dependencies:
      #   pip install pyModeS watchdog rich
      #
      # Output: one hex string per valid DF17/18 frame appended to OUTPUT_FILE
      # Run decoder.py in a second terminal to display traffic.

      from PyQt5 import Qt
      from gnuradio import qtgui
      from gnuradio import blocks
      from gnuradio import filter
      from gnuradio.filter import firdes
      from gnuradio import gr
      from gnuradio.fft import window
      import sys
      import signal
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from gnuradio import eng_notation
      from gnuradio import iio
      import numpy as np
      import sip

      # ── output file watched by decoder.py ────────────────────────────────────────
      OUTPUT_FILE = "/home/bri/workspace/mode_s_decode/controlpathsdotcom/adsb_bursts.txt"


      # ─────────────────────────────────────────────────────────────────────────────
      #  Embedded Python Block — ADS-B frame extractor
      #
      #  Input:  float stream — thresholded OOK signal (0.0 / 1.0) at SAMP_RATE
      #  Output: passthrough of input (connect to time sink for monitoring)
      #
      #  Signal timing at 5 Msps / 1 Mbps:
      #    samples_per_bit  = 5
      #    preamble         = 8 µs  → 8 chips × 5 samples = 40 samples
      #    DF17/18 payload  = 112 bits → 560 samples
      #    total frame      = 600 samples
      #
      #  Preamble chip pattern (half-bit level, 1 sample per chip):
      #    1 1 0 0 1 0 1 0 0 0 0 0 0 0 0 0   (16 chips = 8 µs at 2 chips/µs)
      #  Sampled at 5 Msps → each chip = 2.5 samples, so we look at the
      #  centre sample of each half-bit window.
      # ─────────────────────────────────────────────────────────────────────────────

      class adsb_frame_extractor(gr.sync_block):
          """
          Detects ADS-B (DF17/18) frames in a thresholded OOK float stream.
          Validates CRC and writes hex strings to OUTPUT_FILE.
          """

          SAMP_RATE       = 5_000_000
          BIT_RATE        = 1_000_000
          SPB             = SAMP_RATE // BIT_RATE   # samples per bit = 5
          # Preamble: 8 µs of known chip pattern before the data field.
          # At 5 Msps each bit = 5 samples.  PPM encoding means each bit is
          # represented by a pulse in the first or second half.
          # We detect the preamble by checking the *centre* of each 5-sample bit.
          PREAMBLE_BITS   = [1, 0, 1, 0, 0, 0, 0, 0]   # 8-bit preamble word
          PREAMBLE_LEN    = len(PREAMBLE_BITS)            # 8 bits
          PAYLOAD_BITS    = 112                            # DF17/18 long squitter
          FRAME_SAMPLES   = (PREAMBLE_LEN + PAYLOAD_BITS) * SPB   # 600 samples

          def __init__(self, output_file=OUTPUT_FILE):
              gr.sync_block.__init__(
                  self,
                  name="ADS-B Frame Extractor",
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self._output_file = output_file
              self._buf = np.zeros(self.FRAME_SAMPLES * 4, dtype=np.float32)
              self._buf_len = 0
              self._fh = open(output_file, "a", buffering=1)   # line-buffered

          # ── CRC-24 as specified in ICAO Annex 10 ─────────────────────────────
          _GENERATOR = 0xFFF409

          @staticmethod
          def _crc24(data_bytes):
              crc = 0
              for byte in data_bytes:
                  for i in range(7, -1, -1):
                      bit = (byte >> i) & 1
                      if (crc >> 23) & 1:
                          crc = ((crc << 1) | bit) ^ adsb_frame_extractor._GENERATOR
                      else:
                          crc = (crc << 1) | bit
                      crc &= 0xFFFFFF
              return crc

          # ── sample the centre of each bit period ─────────────────────────────
          def _sample_bits(self, samples, count):
              """Return `count` bits sampled from the centre of each SPB window."""
              centre = self.SPB // 2   # sample index 2 inside each 5-sample bit
              bits = []
              for i in range(count):
                  bits.append(1 if samples[i * self.SPB + centre] > 0.5 else 0)
              return bits

          # ── convert bit list to hex string ────────────────────────────────────
          @staticmethod
          def _bits_to_hex(bits):
              n = len(bits)
              assert n % 8 == 0
              out = []
              for i in range(0, n, 8):
                  byte = 0
                  for b in bits[i:i+8]:
                      byte = (byte << 1) | b
                  out.append(byte)
              return bytes(out).hex().upper()

          # ── GNU Radio work() ─────────────────────────────────────────────────
          def work(self, input_items, output_items):
              inp = input_items[0]
              n   = len(inp)

              # Accumulate into rolling buffer
              needed = self.FRAME_SAMPLES * 2
              self._buf = np.concatenate([self._buf[-needed:], inp])
              buf = self._buf
              L   = len(buf)

              pos = 0
              while pos + self.FRAME_SAMPLES <= L:
                  # Quick gate: first sample must be 1
                  if buf[pos] < 0.5:
                      pos += 1
                      continue

                  # Check preamble bits
                  preamble_ok = True
                  for k, expected in enumerate(self.PREAMBLE_BITS):
                      centre = k * self.SPB + self.SPB // 2
                      got = 1 if buf[pos + centre] > 0.5 else 0
                      if got != expected:
                          preamble_ok = False
                          break

                  if not preamble_ok:
                      pos += 1
                      continue

                  # Extract 112 payload bits that follow the 8-bit preamble
                  payload_start = pos + self.PREAMBLE_LEN * self.SPB
                  if payload_start + self.PAYLOAD_BITS * self.SPB > L:
                      break   # not enough data yet

                  payload_bits = self._sample_bits(
                      buf[payload_start:], self.PAYLOAD_BITS
                  )

                  # Convert to bytes for CRC check
                  hex_str = self._bits_to_hex(payload_bits)
                  raw     = bytes.fromhex(hex_str)

                  # Downlink Format lives in the top 5 bits of byte 0
                  df = raw[0] >> 3

                  if df in (17, 18):
                      # CRC covers bytes 0..13; last 3 bytes ARE the parity
                      msg_bytes = raw[:11]
                      parity    = raw[11:14]
                      computed  = self._crc24(msg_bytes)
                      received  = int.from_bytes(parity, "big")

                      if computed == received:
                          self._fh.write(hex_str + "\n")

                  # Advance past this frame to avoid overlapping detections
                  pos += self.PAYLOAD_BITS * self.SPB

              output_items[0][:n] = inp
              return n


      # ─────────────────────────────────────────────────────────────────────────────
      #  Top-level GNU Radio flowgraph
      # ─────────────────────────────────────────────────────────────────────────────

      class modes_receiver(gr.top_block, Qt.QWidget):

          def __init__(self):
              gr.top_block.__init__(self, "ADS-B Receiver", catch_exceptions=True)
              Qt.QWidget.__init__(self)
              self.setWindowTitle("ADS-B Receiver — 1090 MHz")
              qtgui.util.check_set_qss()
              try:
                  self.setWindowIcon(Qt.QIcon.fromTheme('gnuradio-grc'))
              except BaseException as exc:
                  print(f"Qt GUI: Could not set Icon: {str(exc)}", file=sys.stderr)

              self.top_scroll_layout = Qt.QVBoxLayout()
              self.setLayout(self.top_scroll_layout)
              self.top_scroll = Qt.QScrollArea()
              self.top_scroll.setFrameStyle(Qt.QFrame.NoFrame)
              self.top_scroll_layout.addWidget(self.top_scroll)
              self.top_scroll.setWidgetResizable(True)
              self.top_widget = Qt.QWidget()
              self.top_scroll.setWidget(self.top_widget)
              self.top_layout = Qt.QVBoxLayout(self.top_widget)
              self.top_grid_layout = Qt.QGridLayout()
              self.top_layout.addLayout(self.top_grid_layout)

              self.settings = Qt.QSettings("GNU Radio", "modes_receiver")
              try:
                  geometry = self.settings.value("geometry")
                  if geometry:
                      self.restoreGeometry(geometry)
              except BaseException as exc:
                  print(f"Qt GUI: Could not restore geometry: {str(exc)}", file=sys.stderr)

              # ── Variables ────────────────────────────────────────────────────
              #
              # 5 Msps is critical — the Python block's timing constants assume it.
              # Do NOT change samp_rate without also updating SPB in the block above.
              #
              self.samp_rate   = samp_rate   = 5_000_000
              self.center_freq = center_freq = 1_090_000_000

              # ── PlutoSDR source ──────────────────────────────────────────────
              self.iio_pluto_source_0 = iio.fmcomms2_source_fc32(
                  'ip:pluto.local' if 'ip:pluto.local' else iio.get_pluto_uri(),
                  [True, True], 64000
              )
              self.iio_pluto_source_0.set_len_tag_key('packet_len')
              self.iio_pluto_source_0.set_frequency(center_freq)
              self.iio_pluto_source_0.set_samplerate(samp_rate)
              self.iio_pluto_source_0.set_gain_mode(0, 'manual')
              self.iio_pluto_source_0.set_gain(0, 30)       # tune 20–40 dB to taste
              self.iio_pluto_source_0.set_quadrature(True)
              self.iio_pluto_source_0.set_rfdc(True)
              self.iio_pluto_source_0.set_bbdc(True)
              self.iio_pluto_source_0.set_filter_params('Auto', '', 0, 0)

              # ── IQ → envelope ────────────────────────────────────────────────
              # complex_to_mag gives the true RF envelope (sqrt of power).
              # Do NOT use complex_to_mag_squared — it distorts pulse shapes and
              # makes threshold tuning very environment-sensitive.
              self.blocks_complex_to_mag_0 = blocks.complex_to_mag(1)

              # ── Low-pass filter ──────────────────────────────────────────────
              # Cuts off above ~1.5 MHz to reject adjacent interference while
              # keeping ADS-B pulse edges (1 Mbps → 1 MHz Nyquist) intact.
              # Transition band 1.5–2.0 MHz keeps group delay low.
              self.low_pass_filter_0 = filter.fir_filter_fff(
                  1,                          # decimation = 1 (keep 5 Msps)
                  firdes.low_pass(
                      1,                      # gain
                      samp_rate,              # sampling rate
                      1_500_000,              # cutoff Hz
                      500_000,                # transition width Hz
                      window.WIN_HAMMING,
                      6.76
                  )
              )

              # ── Threshold → binary OOK ───────────────────────────────────────
              # Low threshold (hysteresis lower edge):  adjust if noise triggers
              # High threshold (hysteresis upper edge): adjust if signal clipped
              # Start here and tune while watching the time sink:
              #   - If you see no pulses:  lower both values
              #   - If noise fills gaps:   raise the low value
              # Rule of thumb: high ≈ 3–5× noise floor; low ≈ 0.5× high.
              self.blocks_threshold_ff_0 = blocks.threshold_ff(0.01, 0.03, 0)

              # ── ADS-B frame extractor (embedded Python block) ────────────────
              self.adsb_extractor = adsb_frame_extractor(OUTPUT_FILE)

              # ── Qt sinks ─────────────────────────────────────────────────────
              self.qtgui_waterfall_sink_x_0 = qtgui.waterfall_sink_c(
                  1024, window.WIN_BLACKMAN_hARRIS,
                  center_freq, samp_rate, "", 1, None
              )
              self.qtgui_waterfall_sink_x_0.set_update_time(0.10)
              self.qtgui_waterfall_sink_x_0.enable_grid(False)
              self.qtgui_waterfall_sink_x_0.enable_axis_labels(True)
              self.qtgui_waterfall_sink_x_0.set_intensity_range(-140, 10)
              self._qtgui_waterfall_sink_x_0_win = sip.wrapinstance(
                  self.qtgui_waterfall_sink_x_0.qwidget(), Qt.QWidget)
              self.top_layout.addWidget(self._qtgui_waterfall_sink_x_0_win)

              self.qtgui_freq_sink_x_0 = qtgui.freq_sink_c(
                  1024, window.WIN_BLACKMAN_hARRIS,
                  center_freq, samp_rate, "", 1, None
              )
              self.qtgui_freq_sink_x_0.set_update_time(0.10)
              self.qtgui_freq_sink_x_0.set_y_axis(-140, 10)
              self.qtgui_freq_sink_x_0.set_y_label('Relative Gain', 'dB')
              self.qtgui_freq_sink_x_0.enable_autoscale(False)
              self.qtgui_freq_sink_x_0.enable_grid(False)
              self.qtgui_freq_sink_x_0.set_fft_average(1.0)
              self._qtgui_freq_sink_x_0_win = sip.wrapinstance(
                  self.qtgui_freq_sink_x_0.qwidget(), Qt.QWidget)
              self.top_layout.addWidget(self._qtgui_freq_sink_x_0_win)

              # Time sink shows raw envelope (blue) and thresholded OOK (red)
              self.qtgui_time_sink_x_0_0 = qtgui.time_sink_f(
                  40000, samp_rate, 'OOK Decoder', 2, None
              )
              self.qtgui_time_sink_x_0_0.set_update_time(0.10)
              self.qtgui_time_sink_x_0_0.set_y_axis(-0.1, 1.5)
              self.qtgui_time_sink_x_0_0.set_y_label('Amplitude', "")
              self.qtgui_time_sink_x_0_0.enable_tags(True)
              self.qtgui_time_sink_x_0_0.set_trigger_mode(
                  qtgui.TRIG_MODE_FREE, qtgui.TRIG_SLOPE_POS, 0.0, 0, 0, "")
              self.qtgui_time_sink_x_0_0.enable_autoscale(False)
              self.qtgui_time_sink_x_0_0.enable_grid(True)

              labels = ['Envelope (post-LPF)', 'OOK binary',
                        '', '', '', '', '', '', '', '']
              colors = ['blue', 'red', 'green', 'black', 'cyan',
                        'magenta', 'yellow', 'dark red', 'dark green', 'dark blue']
              for i in range(2):
                  self.qtgui_time_sink_x_0_0.set_line_label(i, labels[i])
                  self.qtgui_time_sink_x_0_0.set_line_color(i, colors[i])
                  self.qtgui_time_sink_x_0_0.set_line_width(i, 1)
                  self.qtgui_time_sink_x_0_0.set_line_alpha(i, 1.0)

              self._qtgui_time_sink_x_0_0_win = sip.wrapinstance(
                  self.qtgui_time_sink_x_0_0.qwidget(), Qt.QWidget)
              self.top_layout.addWidget(self._qtgui_time_sink_x_0_0_win)

              # ── Connections ───────────────────────────────────────────────────
              #
              #  PlutoSDR ──► complex_to_mag ──► LPF ──► threshold ──► extractor
              #         │                  │                    │
              #         ▼                  ▼                    ▼
              #    freq sink        time sink [0]          time sink [1]
              #    waterfall
              #
              self.connect((self.iio_pluto_source_0,    0), (self.blocks_complex_to_mag_0,  0))
              self.connect((self.iio_pluto_source_0,    0), (self.qtgui_freq_sink_x_0,      0))
              self.connect((self.iio_pluto_source_0,    0), (self.qtgui_waterfall_sink_x_0, 0))
              self.connect((self.blocks_complex_to_mag_0, 0), (self.low_pass_filter_0,      0))
              self.connect((self.low_pass_filter_0,     0), (self.qtgui_time_sink_x_0_0,   0))
              self.connect((self.low_pass_filter_0,     0), (self.blocks_threshold_ff_0,    0))
              self.connect((self.blocks_threshold_ff_0, 0), (self.adsb_extractor,           0))
              self.connect((self.adsb_extractor,        0), (self.qtgui_time_sink_x_0_0,   1))

          def closeEvent(self, event):
              self.settings = Qt.QSettings("GNU Radio", "modes_receiver")
              self.settings.setValue("geometry", self.saveGeometry())
              self.stop()
              self.wait()
              event.accept()

          def get_samp_rate(self):
              return self.samp_rate

          def set_samp_rate(self, samp_rate):
              self.samp_rate = samp_rate
              self.iio_pluto_source_0.set_samplerate(self.samp_rate)
              self.low_pass_filter_0.set_taps(firdes.low_pass(
                  1, self.samp_rate, 1_500_000, 500_000, window.WIN_HAMMING, 6.76))
              self.qtgui_freq_sink_x_0.set_frequency_range(self.center_freq, self.samp_rate)
              self.qtgui_time_sink_x_0_0.set_samp_rate(self.samp_rate)
              self.qtgui_waterfall_sink_x_0.set_frequency_range(self.center_freq, self.samp_rate)

          def get_center_freq(self):
              return self.center_freq

          def set_center_freq(self, center_freq):
              self.center_freq = center_freq
              self.iio_pluto_source_0.set_frequency(self.center_freq)
              self.qtgui_freq_sink_x_0.set_frequency_range(self.center_freq, self.samp_rate)
              self.qtgui_waterfall_sink_x_0.set_frequency_range(self.center_freq, self.samp_rate)


      def main(top_block_cls=modes_receiver, options=None):
          qapp = Qt.QApplication(sys.argv)
          tb = top_block_cls()
          tb.start()
          tb.show()

          def sig_handler(sig=None, frame=None):
              tb.stop()
              tb.wait()
              Qt.QApplication.quit()

          signal.signal(signal.SIGINT,  sig_handler)
          signal.signal(signal.SIGTERM, sig_handler)

          timer = Qt.QTimer()
          timer.start(500)
          timer.timeout.connect(lambda: None)
          qapp.exec_()


      if __name__ == '__main__':
          main()
    alias: ADS-B Frame
    output_file: '"/home/bri/workspace/mode_s_decode/controlpathsdotcom/adsb_bursts.txt"'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import pmt
      from gnuradio import gr

      class adsb_extractor(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="ADSB Bit Extractor",
                  in_sig=[np.dtype(np.uint8)],
                  out_sig=[np.dtype(np.uint8)])
              self.capturing = False
              self.buffer = []

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Check for tags in the current window
              tags = self.get_tags_in_range(0, 0, len(in0))
              for tag in tags:
                  if tag.key == pmt.intern("preamble"):
                      self.capturing = True
                      self.buffer = []

              # Process samples
              for i, val in enumerate(in0):
                  if self.capturing:
                      self.buffer.append(val)
                      if len(self.buffer) == 112:  # ADS-B message length
                          bits_str = ''.join(str(int(b)) for b in self.buffer)
                          print(f"ADS-B: {bits_str}")
                          self.capturing = False
                          self.buffer = []
                  out[i] = val

              return len(out)
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      preamble_found = False

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Post processing of collected data"""

          def __init__(self, file=''):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Binary File Processor',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.filename = file
          #1010001010000000
          def find_sequence_in_binary_file(filename, sequence="1010001010000000"):
              """Check a binary file for the presence of a specific bit sequence.
              
              Args:
                  filename (str): Path to the binary file to check
                  sequence (str): The bit sequence to search for (e.g., "1010001010000000")
              
              Returns:
                  list: List of byte offsets where the sequence starts, or empty list if not found
              """
              if not sequence or not all(c in '01' for c in sequence):
                  raise ValueError("Sequence must be a string of 0s and 1s (e.g., '10100010')")

              # Convert the bit sequence to bytes (pad to full bytes)
              # e.g., "1010001010000000" → 2 bytes
              num_bytes = (len(sequence) + 7) // 8
              # Pad with leading zeros if needed
              padded_sequence = sequence.zfill(num_bytes * 8)
              sequence_int = int(padded_sequence, 2)
              sequence_bytes = sequence_int.to_bytes(num_bytes, byteorder='big')

              # Also keep the original bit string for verification
              sequence_bits = sequence

              found_positions = []

              try:
                  with open(filename, 'rb') as file:
                      chunk_size = 65536  # 64 KB chunks
                      buffer = b''
                      buffer_bits = ""  # Keep track of bits for overlap

                      while True:
                          chunk = file.read(chunk_size)
                          if not chunk:
                              break

                          # Convert chunk to binary string (e.g., b'\x01\x02' → "0000000100000010")
                          chunk_bits = ''.join(format(byte, '08b') for byte in chunk)

                          # Combine with previous buffer's bits (for overlap)
                          combined_bits = buffer_bits + chunk_bits

                          # Search for the sequence in the combined bits
                          start = 0
                          while True:
                              pos = combined_bits.find(sequence_bits, start)
                              if pos == -1:
                                  break
                              # Convert bit position to byte position
                              byte_pos = (len(buffer) * 8 + pos) // 8
                              found_positions.append(byte_pos)
                              start = pos + 1  # Continue searching for overlapping matches
                              preamble_found = True

                          # Update buffer for next iteration (keep enough for overlap)
                          buffer_bits = combined_bits[-(len(sequence_bits) - 1):]
                          buffer = chunk  # Keep full chunk for byte position calculation

                  return found_positions

              except FileNotFoundError:
                  print(f"Error: File '{filename}' not found.")
                  return []
              except Exception as e:
                  print(f"Error reading file: {e}")
                  return []
          
          # def find_sequence_in_binary_file(filename, sequence="1010001010000000"):
          #     """ Check a binary file for the presence of a specific bit sequence.
              
          #     Args:
          #         filename (str): Path to the binary file to check
          #         sequence (str): The bit sequence to search for (default: "10011010")
              
          #     Returns:
          #         bool: True if sequence is found, False otherwise
          #     """
          #     global preamble_found

          #     # Convert sequence to bytes for comparison
          #     sequence_bytes = int(sequence, 2).to_bytes(1, byteorder='big')
              
          #     try:
          #         with open(filename, 'rb') as file:
          #             # Read the file in chunks to handle large files efficiently
          #             chunk_size = 1024
          #             buffer = b''
                      
          #             while True:
          #                 chunk = file.read(chunk_size)
          #                 if not chunk:
          #                     break
                          
          #                 # Append new data to buffer
          #                 buffer += chunk
                          
          #                 # Check for the sequence in the buffer
          #                 # We need to check overlapping sequences
          #                 for i in range(len(buffer) - len(sequence) + 1):
          #                     # Extract a byte from the buffer
          #                     byte = buffer[i]
          #                     # Check if the byte matches the sequence
          #                     if byte == sequence_bytes[0]:
          #                         # Verify the exact bit pattern
          #                         # Convert byte to 8-bit binary string
          #                         byte_bits = format(byte, '08b')
          #                         # Check if the sequence matches the last 8 bits
          #                         if byte_bits == sequence:
          #                             return preamble_found == True
                          
          #                 # Keep only the overlapping part for next iteration
          #                 # This ensures we don't miss sequences that span across chunks
          #                 overlap = len(sequence) - 1
          #                 if len(buffer) > overlap:
          #                     buffer = buffer[-overlap:]
                      
          #             return False
                      
          #     except FileNotFoundError:
          #         print(f"Error: File '{filename}' not found.")
          #         return False
          #     except Exception as e:
          #         print(f"Error reading file: {e}")
          #         return False
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              global preamble_found
              output_items[0][:] = input_items[0]
              
              # search for preamble 10011010
              if preamble_found:
                  print("Sequence '10011010' found in the file!")
              # else:
              #     print("Sequence '10011010' not found in the file.")
              
              return len(output_items[0])
          

      # if preamble found - save next 112 bits
      # convert to hex
      # save as a message

      # import pyModeS

      # global msg_hex

      # def extract_adsb_message(bits, start_index, preamble_found,msg):
      #     """
      #     Extract the 112 bits immediately following a detected preamble.

      #     Parameters:
      #         bits (str): Binary string containing 0s and 1s.
      #         start_index (int): Index immediately after the preamble.
      #         preamble_found (bool): True if a valid preamble was detected.

      #     Returns:
      #         str or None: 112-bit ADS-B message, or None if unavailable.
      #     """
      #     if preamble_found and start_index + 112 <= len(bits):
      #         message = bits[start_index:start_index + 112]
      #         msg_hex = format(int(message, 2), "028X")
      #         return msg_hex

      #     return None

      # result = pyModeS.decode(msg_hex)
      # print(result)
      # # {
      # #     'df': 17,
      # #     'icao': '406B90',
      # #     'crc_valid': True,
      # #     'typecode': 4,
      # #     'bds': '0,8',
      # #     'callsign': 'EZY85MH',
      # #     'category': 0,
      # #     'wake_vortex': 'No category information',
      # # }






















          # Python code to convert binary number
          # into hexadecimal number

          # function to convert
          # binary to hexadecimal

          # def binToHexa(n):
          #     bnum = int(n)
          #     temp = 0
          #     mul = 1
              
          #     # counter to check group of 4
          #     count = 1
              
          #     # char array to store hexadecimal number
          #     hexaDeciNum = ['0'] * 100
              
          #     # counter for hexadecimal number array
          #     i = 0
          #     while bnum != 0:
          #         rem = bnum % 10
          #         temp = temp + (rem*mul)
                  
          #         # check if group of 4 completed
          #         if count % 4 == 0:
                  
          #             # check if temp < 10
          #             if temp < 10:
          #                 hexaDeciNum[i] = chr(temp+48)
          #             else:
          #                 hexaDeciNum[i] = chr(temp+55)
          #             mul = 1
          #             temp = 0
          #             count = 1
          #             i = i+1
                      
          #         # group of 4 is not completed
          #         else:
          #             mul = mul*2
          #             count = count+1
          #         bnum = int(bnum/10)
                  
          #     # check if at end the group of 4 is not
          #     # completed
          #     if count != 1:
          #         hexaDeciNum[i] = chr(temp+48)
                  
          #     # check at end the group of 4 is completed
          #     if count == 1:
          #         i = i-1
                  
          #     # printing hexadecimal number
          #     # array in reverse order
          #     print("\n Hexadecimal equivalent of {}:  ".format(n), end="")
          #     while i >= 0:
          #         print(end=hexaDeciNum[i])
          #         i = i-1
    file: '''/home/bri/workspace/mode_s_decode/controlpathsdotcom/raw_adsb_files/adsb_raw_4000000Hz_1783773546.real_float'''
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="ADS-B Detector",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              # Keep enough history so packets spanning buffers aren't missed
              self.history = np.zeros(512, dtype=np.float32)

              # Prevent duplicate prints
              self.last_detection = -100000

          ####################################################################
          # Detect one ADS-B preamble (32 samples @ 4 MHz)
          ####################################################################
          def is_preamble(self, w):

              if len(w) != 32:
                  return False

              pulse = np.mean(np.concatenate((
                  w[0:2],
                  w[4:6],
                  w[14:16],
                  w[18:20]
              )))

              gap = np.mean(np.concatenate((
                  w[2:4],
                  w[6:14],
                  w[16:18],
                  w[20:32]
              )))

              if pulse < 0.02:
                  return False

              if pulse < 3 * gap:
                  return False

              return True

          ####################################################################
          # Search an entire buffer
          ####################################################################
          def find_preambles(self, samples):

              detections = []

              for i in range(len(samples) - 32):

                  if self.is_preamble(samples[i:i+32]):
                      detections.append(i)

              return detections

          ####################################################################
          # GNU Radio work()
          ####################################################################
          def work(self, input_items, output_items):

              x = input_items[0]
              y = output_items[0]

              y[:] = x

              samples = np.concatenate((self.history, x))

              detections = self.find_preambles(samples)

              for d in detections:

                  if d - self.last_detection > 64:

                      print("Detection:", d)
                      print(np.round(samples[d:d+40], 3))
                      print()

                      self.last_detection = d

              self.history = samples[-512:]

              return len(y)
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '262144'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from time import time
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '2.5'
    cutoff_freq: '1000000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200000'
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: OOK Decoder
    nconnections: '3'
    size: '256'
    srate: samp_rate
    tr_level: '0.02'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '0.02'
    ymin: '-0.00001'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: OOK Decoder
    size: '256'
    srate: samp_rate
    tr_level: '0.02'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '0.02'
    ymin: '-0.00001'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    int_max: '-20'
    int_min: '-100'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_char_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_3, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_null_source_0, '0', epy_block_2, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '1']
- [epy_block_2, '0', blocks_null_sink_0, '0']
- [epy_block_3, '0', qtgui_time_sink_x_0_0, '2']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
