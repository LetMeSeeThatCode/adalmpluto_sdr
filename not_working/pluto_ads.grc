options:
  parameters:
    author: bri
    generate_options: qt_gui
    id: pluto_ads
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1'
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.01'
    init: '0'
    low: '0.0002'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='ADS-B Sync',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.state = "SEARCHING"
              self.buffer = []
              self.preamble_pattern = [1, 1, 1, 1, 0, 0, 0, 0] # Simplified example

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # This is a simplified loop. In a real block, you'd use a 
              # sliding window to find the preamble.
              for i in range(len(in0)):
                  if self.state == "SEARCHING":
                      self.buffer.append(in0[i])
                      # Check if the end of the buffer matches the preamble
                      if len(self.buffer) >= len(self.preamble_pattern):
                          if self.buffer[-len(self.preamble_pattern):] == self.preamble_pattern:
                              self.state = "CAPTURING"
                              self.buffer = [] # Clear buffer to start capturing message
                  
                  elif self.state == "CAPTURING":
                      self.buffer.append(in0[i])
                      if len(self.buffer) >= 112: # ADS-B message length
                          # Output the captured 112 bits
                          out[0:112] = np.array(self.buffer)
                          self.state = "SEARCHING"
                          self.buffer = []
                          return 112 # Tell GNU Radio we produced 112 samples
              
              return 0 # Produced nothing yet
    example_param: '1.0'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '1090000000'
    gain1: '''manual'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 1090e6
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    tr_level: '2e-5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1e-3'
    ymin: '-1e-7'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_complex_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
