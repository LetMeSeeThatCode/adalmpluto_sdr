options:
  parameters:
    author: Bri
    description: Project for Seminar EIM
    generate_options: qt_gui
    id: modes_receiver
    output_language: python
    title: PlutoSDR - ADS-B signal Receiver
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '1090000000'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '''/home/bri/workspace/mode_s_decode/controlpathsdotcom/raw_adsb_files/adsb_raw_''+samp_rate_string+''Hz_''+timestamp+''_mag_char'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: samp_rate_string
  id: variable
  parameters:
    value: str(int(samp_rate))
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: str(int(time()))
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    alias: mag
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '262144'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from time import time
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '2.5'
    cutoff_freq: '1000000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200000'
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Signal Magnitude
    size: '512'
    srate: samp_rate
    tr_level: '0.02'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '0.02'
    ymin: '-0.00001'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    int_max: '-20'
    int_min: '-100'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
